# Keil uVision project c51.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: c51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ../src/main/: main.c
  group lib
    ../src/lib/: c51.h c51.c
